# IAR project WWDT_ReloadCounter.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M091 series Nuvoton M091 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M091\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WWDT_ReloadCounter.bin
  ILINK.IlinkOutputFile: WWDT_ReloadCounter.out
  ILINK.IlinkIcfFile: WWDT_ReloadCounter.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M091/Source/IAR/: startup_M091.s
    ../../../../Library/Device/Nuvoton/M091/Source/: system_M091.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c wwdt.c
  group User
    ../: main.c
