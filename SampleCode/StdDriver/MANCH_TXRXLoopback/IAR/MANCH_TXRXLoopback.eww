<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MANCH_TXRXLoopback.ewp</path>
  </project>
  <batchBuild/>
</workspace>


