# Keil uVision project UART_AutoBaudRate.uvprojx, settings and files
target UART_AutoBaudRate (ARM-ADS)
  device: M091YD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: UART_AutoBaudRate
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M091\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M091.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M091/Source/ARM/: startup_M091.s
    ../../../../Library/Device/Nuvoton/M091/Source/: system_M091.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c
