# IAR project BPWM_OutputWaveform.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M091 series Nuvoton M091 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M091\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BPWM_OutputWaveform.bin
  ILINK.IlinkOutputFile: BPWM_OutputWaveform.out
  ILINK.IlinkIcfFile: BPWM_OutputWaveform.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M091/Source/IAR/: startup_M091.s
    ../../../../Library/Device/Nuvoton/M091/Source/: system_M091.c
  group Library
    ../../../../Library/StdDriver/src/: bpwm.c clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
