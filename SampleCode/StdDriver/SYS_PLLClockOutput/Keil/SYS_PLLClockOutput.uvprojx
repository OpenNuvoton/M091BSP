# Keil uVision project SYS_PLLClockOutput.uvprojx, settings and files
target SYS_PLLClockOutput (ARM-ADS)
  device: M031GTD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: SYS_PLLClockOutput
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M091\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M091.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M091/Source/: system_M091.c
    ../../../../Library/Device/Nuvoton/M091/Source/ARM/: startup_M091.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c gpio.c sys.c
  group User
    ../: main.c
