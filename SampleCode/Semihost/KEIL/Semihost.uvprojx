# Keil uVision project Semihost.uvprojx, settings and files
target Semihost (6120000::V6.12::.\ARMCLANG)
  device: M091YD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M091\Include;..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M091.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M091/Source/: system_M091.c
    ../../../Library/Device/Nuvoton/M091/Source/ARM/: startup_M091.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
